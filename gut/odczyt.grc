options:
  parameters:
    generate_options: qt_gui
    id: test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: band
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/dr/Muzyka/discopolo/atak3
    type: complex
  states: {}
- name: iio_pluto_source_1
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: band
    bbdc: 'True'
    buffer_size: '16384'
    frequency: '433921000'
    gain1: '''manual'''
    manual_gain1: '30'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '1000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: band
    fc: '433921000'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: band
    fc: '433921000'
    fftsize: '1024'
    rate: '5'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: band
    fc: '433921000'
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [iio_pluto_source_1, '0', blocks_file_sink_1, '0']
- [iio_pluto_source_1, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_1, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
